PACKAGE_INSTALL:append = " fluent-bit prometheus node-exporter"
